# Repository PeraZver/MP3-Player-Marko

## EAGLE design HW/MP3_Player.brd

Parts:
C1, C6, C17, C21, C25: 10µF; EIA3216
C2, C5, C13, C14, C15, C16, C18, C19, C20, C26, C27: 0.1µF; C0603
C3, C8: 22pF; C0603
C4: 470pF; C0603
C7: 4.7μF; C0603K
C9: 1.0µF; C0603
C10, C11: 10nF; C0603
C12: 47nF; C0603
C22: 1µF; C0603
C23, C24: 18p; C0603
C33, C34, C35, C36: 1.0µF; 0805
C37, C38: 2.2µF; 0805
D1, D2: SMF5.0AT1; SOD123FL
F2: PTC0603; 0603
J1: Audio jack; AUDIO-JACK-3.5MM-SMD
J2: LIPO-BATTERY-CONNECTOR; JST-LIPO-CONNECTOR-1.25MM
J3: USD-SDIO-SOCKETJLH; DM3AT-SF-PEJM5
J4: micro USB; USB-B-MICRO-SMD_V03
JP2, JP3, JP4: JUMPER-PAD-3-2OF3_NC_BY_TRACE_SMALL; PAD-JUMPER-3-2OF3_NC_BY_TRACE_YES_SILK_FULL_BOX
LED2: RED; LED-0603
OLED1: UG-2832HSWEG04
Q1: 8MHz; 6X3.2MM
Q2: 12.288MHz; CRYSTAL-SMD-5X3
R1: 1M; R0603
R2, R3, R4, R5: 100k; R0603
R6, R7: 20; R0603
R8, R10, R13, R14, R15, R16, R17: 10k; R0603
R9: 10; R0603
R11: 390K; R0603
R12, R19: 68; R0603
R18: 330; R0603
R23, R24: 22; R0603
S1: Reset; TACTILE-SWITCH-SKSGAAE010
S2: Play/Pause; TACTILE-SWITCH-SKSGAAE010
S3: FWD; TACTILE-SWITCH-SKSGAAE010
S4: BCK; TACTILE-SWITCH-SKSGAAE010
S5: Vol Up; TACTILE-SWITCH-SKSGAAE010
S6: Vol Down; TACTILE-SWITCH-SKSGAAE010
U1: 3.3V/150mA; SOT23-5
U2: 1.8V/100mA; SC70
U3: ATMEGA32U4QFN; QFN-44
U4: VS1053B; LQFP-48
U5: MCP73831; SOT23-5

Connections:
1.8V: C1.A (+), C2.1, C16.1, U2.5 (OUT), U4.5 (CVDD1), U4.7 (CVDD2), U4.24 (CVDD3), U4.31 (CVDD4)
3.3V: C5.1, C6.A (+), C13.1, C14.1, C15.1, C18.1, C19.1, C20.1, C22.1, C35.2, C36.2, J3.P$4 (VCC), OLED1.5 (VBAT), OLED1.7 (VDD), R2.2, R17.2, S2.P$2 (2), S2.P$4 (2), S3.P$2 (2), S3.P$4 (2), S4.P$2 (2), S4.P$4 (2), S5.P$2 (2), S5.P$4 (2), S6.P$2 (2), S6.P$4 (2), U1.5 (OUT), U2.1 (IN), U2.3 (EN), U3.6 (UCAP), U3.14 (VCC), U3.24 (AVCC), U3.34 (VCC), U3.44 (AVCC), U4.6 (IOVDD1), U4.14 (IOVDD2), U4.19 (IOVDD3), U4.32 (TEST), U4.38 (AVDD1), U4.43 (AVDD2), U4.45 (AVDD3)
G1: R3.2, U4.9 (GPIO2/DCLK), U4.10 (GPIO3/SDATA), U4.11 (GPIO6), U4.12 (GPIO7)
G2: R4.2, U4.25 (GPIO5/I2C_MCLK), U4.33 (GPIO0/I2S_SCLK), U4.34 (GPIO1/I2S_SDATA), U4.36 (GPIO4/I2S_LROUT)
GBUF: JP4.1, R9.2, U4.42 (GBUF)
GND: C1.C (-), C2.2, C3.1, C4.2, C5.2, C6.C (-), C7.2, C8.1, C9.1, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.C (-), C18.2, C19.2, C20.2, C22.2, C23.1, C24.1, C26.2, C27.2, C35.1, C36.1, C37.1, C38.1, J2.P$2 (-), J3.P$6 (GND), J3.P$9 (CD1), J3.P$10 (CD1), J3.P$11 (CD2), J3.P$12 (CD2), J3.P$13 (SHIELD), J3.P$14 (SHIELD), J4.GND, JP4.3, LED2.C, OLED1.6 (VSS), R3.1, R4.1, R5.1, R8.1, R10.1, R11.1, R13.1, R14.1, R15.1, R16.1, S1.P$1 (1), S1.P$3 (1), U1.2 (GND), U2.2 (GND), U3.5 (UGND), U3.15 (GND), U3.23 (GND), U3.35 (GND), U3.43 (GND), U4.4 (DGND1), U4.16 (DGND2), U4.20 (DGND3), U4.21 (DGND4), U4.22 (DGND5), U4.35 (DGND6), U4.37 (AGND1), U4.40 (AGND2), U4.41 (AGND3), U4.47 (AGND4), U5.2 (VSS)
LEFT: JP2.1, R7.2, U4.46 (LEFT)
MIDI-RX: R2.1, U4.26 (RX)
MISO: J3.P$7 (DAT0), U3.11 (PB3(MISO)), U4.30 (S0)
MOSI: J3.P$3 (CMD), OLED1.12 (SDIN), U3.10 (PB2(MOSI)), U4.29 (SI)
MP3-CS: U3.20 (PD2(RX)), U4.23 (XCS)
MP3-DCS: U3.21 (PD3(TX)), U4.13 (XDCS/BSYNC)
MP3-DREQ: U3.18 (PD0(SCL)), U4.8 (DREQ)
MP3-RST: R5.2, U3.19 (PD1(SDA)), U4.3 (XRESET)
unnamed: R18.2, U3.41 (PF0(ADC0))
unnamed: C12.1, R9.1
unnamed: C10.1, R6.1
unnamed: R13.2, U5.5 (PROG)
unnamed: C11.1, R7.1
unnamed: R8.2, S6.P$1 (1), S6.P$3 (1), U3.40 (PF1(ADC1))
unnamed: LED2.A, R18.1
unnamed: C3.2, Q2.3 (2), R1.2, U4.18 (XTAL1/MCLK)
unnamed: C8.2, Q2.1, R1.1, U4.17 (XTAL2)
unnamed: J1.SLEEVE, JP4.2
unnamed: J1.TIP (LEFT), JP2.2
unnamed: J4.D-, R24.1
unnamed: R10.2, S2.P$1 (1), S2.P$3 (1), U3.36 (PF7(ADC7))
unnamed: R14.2, S3.P$1 (1), S3.P$3 (1), U3.37 (PF6(ADC6))
unnamed: C23.2, Q1.P$2 (2), U3.17 (XTAL1)
unnamed: C24.2, Q1.P$1 (1), U3.16 (XTAL2)
unnamed: R23.2, U3.4 (D+)
unnamed: R24.2, U3.3 (D-)
unnamed: F2.1, J4.VBUS (VCC)
unnamed: C21.C (-), JP2.3
unnamed: J4.D+, R23.1
unnamed: R15.2, S4.P$1 (1), S4.P$3 (1), U3.38 (PF5(ADC5))
unnamed: C25.C (-), JP3.3
unnamed: J1.RING (RIGHT), JP3.2
unnamed: C21.A (+), C26.1, R12.1
unnamed: C9.2, U4.44 (RCAP)
unnamed: C33.1, OLED1.2 (C2-)
unnamed: C33.2, OLED1.1 (C2+)
unnamed: C34.1, OLED1.4 (C1-)
unnamed: C34.2, OLED1.3 (C1+)
unnamed: OLED1.13 (IREF), R11.2
unnamed: C37.2, OLED1.14 (VCOMH)
unnamed: C38.2, OLED1.15 (VCC)
unnamed: C4.1, U1.4 (BP)
OLED-CS: OLED1.8 (CS#), U3.25 (PD4(ADC8))
OLED-DC: OLED1.10 (D/C#), U3.27 (PD7(ADC10))
OLED-RST: OLED1.9 (RES#), U3.26 (PD6(ADC9))
PWM_L: R12.2, U3.30 (PB6(ADC13))
PWM_L1: C25.A (+), C27.1, R19.1
PWM_LEFT: R16.2, S5.P$1 (1), S5.P$3 (1), U3.39 (PF4(ADC4))
PWM_R: R19.2, U3.29 (PB5(ADC12))
RIGHT: JP3.1, R6.2, U4.39 (RIGHT)
RST: R17.1, S1.P$2 (2), S1.P$4 (2), U3.13 (!RESET)
SCK: J3.P$5 (CLK), OLED1.11 (SCLK), U3.9 (PB1(SCK)), U4.28 (SCLK)
SD-CS: J3.P$2 (CD/DAT3), U3.8 (PB0(SS))
VBAT: D1.A, J2.P$1 (+), U5.3 (VBAT)
VIN: C7.1, D1.C, D2.C, U1.1 (IN), U1.3 (EN)
VUSB: C17.A (+), D2.A, F2.2, U3.7 (VBUS), U5.4 (VIN)

Notes on the sheet:
uSD Interface
Power
Line Out to Speakers or Amplifier
MP3 Decoder
150mA
Microcontroller
Battery charger: MCP73831 ---------------------- for charging current of 100 mA, R6 is 10k
Diodes D1 and D2 disconnect battery when USB cable is plugged. Downside is forward voltage drop
Circuit diagram
Author: Pero K.
CD 01
v2.0
OLED Interface
(Optional)
TO DO: _______________ * Change buttons to the pins with interrupt functions * No need forexternal pull up resistors, internal can be activated with PORTxn register

Board: 2 copper layers, 210.0 x 15.0 mm, 81 parts (14 on the bottom side), 62 nets.

Other parts of the board:
DRILEGEND: DRILEGEND
U$1: A4L-LOC

File HW/MP3_Player BOM.txt (part):

Partlist exported from D:/Elektronika/MP3 Player Marko/HW/MP3_Player.sch at 7/12/2016 9:57 PM

Qty Value                  Device                                 Package                                         Parts                            Description                                                                                                                                                                                                                                             
1                          AUDIO-JACKSMD2                         AUDIO-JACK-3.5MM-SMD                            J1                               3.5mm Audio Jack                                                                                                                                                                                                                                        
3                          JUMPER-PAD-3-2OF3_NC_BY_TRACE_SMALL    PAD-JUMPER-3-2OF3_NC_BY_TRACE_YES_SILK_FULL_BOX JP2, JP3, JP4                                                                                                                                                                                                                                                                            
1                          QUARTZ-CRYSTAL-8MHZQC6CB8.00000F18B23R 6X3.2MM                                         Q1                               Quarz Crystal  QC6CB8.00000F18B23R by QANTEK.                                                                                                                                                                                                           
1                          USB_MICROB_PLUGCONN-11752              USB-B-MICRO-SMD_V03                             J4                               USB Micro-B connectors                                                                                                                                                                                                                                  
6   0.1µF                  C-EUC0603                              C0603                                           C5, C13, C18, C19, C26, C27      CAPACITOR, European symbol                                                                                                                                                                                                                              
4   1.0µF                  CAP_CERAMIC0805                        0805                                            C33, C34, C35, C36               Ceramic Capacitors                                                                                                                                                                                                                                      
7   10k                    R-EU_R0603                             R0603                                           R8, R10, R13, R14, R15, R16, R17 RESISTOR, European symbol                                                                                                                                                                                                                               
4   10µF                   10UF-16V-10%(TANT)                     EIA3216                                         C6, C17, C21, C25                CAP-00811                                                                                                                                                                                                                                               
2   18p                    C-EUC0603                              C0603                                           C23, C24                         CAPACITOR, European symbol                                                                                                                                                                                                                              
1   1µF                    C-EUC0603                              C0603                                           C22                              CAPACITOR, European symbol                                                                                                                                                                                                                              
2   2.2µF                  CAP_CERAMIC0805                        0805                                            C37, C38                         Ceramic Capacitors                                                                                                                                                                                                                                      
2   22                     R-EU_R0603                             R0603                                           R23, R24                         RESISTOR, European symbol                                                                                                                                                                                                                               
1   3.3V/150mA             V_REG_MIC52053.3V                      SOT23-5                                         U1                               V_REG MIC5205 Standard 3.3V, 5V, and Adjustable 150mA LDO voltage regulator in SOT-23 layout. Micrel part MIC5205. BP (by-pass) pin is used to lower output noise with 470pF cap, may be left open. On the adjustable version BP is used to set output. 
1   330                    R-EU_R0603                             R0603                                           R18                              RESISTOR, European symbol                                                                                                                                                                                                                               
1   390K                   RESISTOR0805                           0805                                            R11                              Resistors                                                                                                                                                                                                                                               
1   4.7µF                  C-EUC0603K                             C0603K                                          C7                               CAPACITOR, European symbol                                                                                                                                                                                                                              
1   470pF                  C-EUC0603                              C0603                                           C4                               CAPACITOR, European symbol                                                                                                                                                                                                                              
2   68                     R-EU_R0603                             R0603                                           R12, R19                         RESISTOR, European symbol                                                                                                                                                                                                                               
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
## Commit log

2016-05-29 Initial commit.
2016-05-29 Added documentation folder
2016-06-05 changed buttons, oscillator and JST connector
2016-06-12 Fix typos
2016-06-17 Changed uSD socket. Components placed
2016-06-17 Comit before 1st autorouter
2016-06-17 Micro USB instead of mini USB. Created "No MP3" variant. Audio jack verified.
2016-06-21 added 3d model. new button.
2016-06-21 git ignore
2016-06-28 Auto router not bad
2016-07-02 completed routing, now just checking
2016-07-02 Completed routing and verified. Added RC filters
2016-07-02 improved .gitignore
2016-07-02 Documentation 3D images. Improved .gitignore
2016-07-02 Revert "Documentation 3D images. Improved .gitignore"
    This reverts commit 04260247c1b8ab6482dbe8aff4bf072e89a26ed3.
2016-07-02 Revert "Revert "Documentation 3D images. Improved .gitignore""
    This reverts commit 87b7abd63b88279df217ce62f86a45873d96780e.
2016-07-02 gerber files generated
2016-07-02 return to last commit
2016-07-02 Revert "gerber files generated"
    This reverts commit 90f40b43d4a083a928ce2398cded0cba18803147.
2016-07-02 Revert "Revert "gerber files generated""
    This reverts commit 3da6fa17a727ae74702837ae0393dc95fa27751b.
2016-07-02 clear the mess
2016-07-12 prettier schematics and BOM
2016-07-12 changed project description
2016-09-01 assembly drawings
2016-09-03 fixing missing wire on schematics
2016-09-27 Introduced to ATmega32u4 and redrew missing lines
2016-09-27 changed OLED footprint
2016-09-29 Autorouter dobar, al bez thermal pada
2016-09-29 routing complete, no orphans
2016-09-29 Autorouter finished
2016-09-29 atmega routed
2016-09-29 routed Oled
2016-09-29 passed DRC
2016-09-30 Silkscreen and music icons
2016-09-30 Fixed silkscreen and ordered
2016-09-30 merged Thermal pad branch
2016-12-10 First software version
2016-12-10 List all files on SD card
2016-12-11 get the playlist in the array of strings using strdup function
2016-12-11 Basic button functionality for all buttons
2016-12-11 Playlist doesn't stop when not-the-last song is over
2016-12-14 OLED display added, works fine
2016-12-14 update gitignore
2016-12-16 counting lines in the text file for playlist
2016-12-16 reading line from text file to find the song name
2016-12-17 test
2016-12-17 reads both playlists
2016-12-18 read long filename using SdFatLib
2016-12-18 button functionality with long names
2016-12-18 OLED works when the TCMPCM is turned off
2016-12-18 OLED workd and TCMPCM works!!!
2016-12-18 works with any SD card, but no OLED (too much memory
2016-12-18 stable code, everything works
2016-12-18 Added documentation
2016-12-19 Using smaller library for OLED, less RAM consumed
2016-12-20 Parsing artist name and the song name
2016-12-20 docu
2016-12-20 3D model and images
2017-02-26 finished release

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-Passives: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
